# Keil uVision project STM32H723.uvprojx, settings and files
target piKaNoneOS (5060960::V5.06 update 7 (build 960)::.\version5.06)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: pikaNewAi +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: E:\LBS-NEW-AI\postbuild.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,PIKA_CONFIG_ENABLE
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Middle\SYSTEM;..\Drivers\BSP\adc;..\Drivers\BSP\dac;..\Drivers\BSP\gpio;..\Drivers\BSP\iic;..\Drivers\BSP\iwdg;..\Drivers\BSP\ospi;..\Drivers\BSP\spi;..\Drivers\BSP\tim;..\Drivers\BSP\uart;..\Middle\DELAY;..\USB\Core\Inc;..\USB\Class\CDC\Inc;..\USB\App;..\USB\Target;..\FATFS;..\Drivers\User\w25qxx;..\Drivers\User\matrix;..\Drivers\User\key;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\Middle\File_IO;..\Drivers\User\music;..\Drivers\DataFile\rawMatrix;..\Drivers\DataFile\list;..\Drivers\DataFile\machine;..\Drivers\DataFile\portAgree;..\Drivers\DataFile\color;..\Drivers\DataFile\gray;..\Drivers\DataFile\motor;..\Drivers\DataFile\touch;..\Drivers\DataFile\ultrasion;..\Drivers\DataFile\dataStruct;..\Drivers\DataFile\cjson;..\Drivers\DataFile\download;..\Drivers\DataFile\ringbufer;..\Drivers\DataFile\entery;..\Drivers\DataFile\blue;..\python\pikascript-core;..\python\pikascript-api;..\Drivers\DataFile\message;..\STM32_MotionFX_Library\Inc;..\Drivers\DataFile\mem;..\Drivers\DataFile\strlist;..\Drivers\DataFile\remote;..\Drivers\User\os;..\Drivers\DataFile\filter;..\Drivers\DataFile\valueType;..\Middle\CTL_CMD;..\Drivers\DataFile\nfc;..\Drivers\DataFile\camer;..\Middle\PID_CONTROL;..\Drivers\DataFile\grayv2;..\Middle\AI\Inc;..\X-CUBE-AI\App
  library: MicroLIB
  memory RVCT4: ROM 0x8020800 size 0xdf800
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: STM32H723\pikaNewAi.sct
  group Dev/IO
    ../Middle/File_IO/: devfile.c
    ../Drivers/DataFile/color/: color.c
    ../Drivers/DataFile/gray/: gray.c
    ../Drivers/DataFile/motor/: motor.c
    ../Drivers/DataFile/touch/: touch.c
    ../Drivers/DataFile/ultrasion/: ultrasion.c
    ../Drivers/DataFile/message/: message.c
    ../Drivers/DataFile/remote/: remote.c
    ../Drivers/DataFile/nfc/: nfc_car.c
    ../Drivers/DataFile/camer/: camer.c
    ../Drivers/DataFile/grayv2/: grayv2.c
  group Dev/data
    ../Drivers/DataFile/rawMatrix/: rawMatrix.c
    ../Drivers/DataFile/list/: dbList.c
    ../Drivers/DataFile/machine/: matchineState.c
    ../Drivers/DataFile/dataStruct/: dataStruct.c
    ../Drivers/DataFile/cjson/: cJSON.c json-maker.c
    ../Drivers/DataFile/entery/: entery.c
    ../Drivers/DataFile/strlist/: strlist.c
    ../Drivers/DataFile/filter/: filter.c
    ../Drivers/DataFile/valueType/: valueType.c
  group USER/DEV
    ../Drivers/User/w25qxx/: w25qxx.c
    ../Drivers/User/key/: key.c
    ../Drivers/User/matrix/: matrix.c
    ../Drivers/User/music/: music.c
    ../Drivers/DataFile/portAgree/: portagree.c
    ../Drivers/DataFile/download/: download.c
    ../Drivers/DataFile/ringbufer/: ringbufer.c
    ../Drivers/DataFile/blue/: blue.c
    ../Core/Src/: pika_config.c
    ../Drivers/DataFile/mem/: mem.c
    ../Drivers/User/os/: os.c
    ../Middle/CTL_CMD/: ctl_cmd.c
    ../Middle/PID_CONTROL/: pid_control.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/User
    ../Drivers/BSP/adc/: adc.c
    ../Drivers/BSP/dac/: dac.c
    ../Drivers/BSP/gpio/: gpio.c
    ../Drivers/BSP/iic/: iic.c
    ../Drivers/BSP/iwdg/: iwdg.c
    ../Drivers/BSP/ospi/: ospi.c
    ../Drivers/BSP/spi/: spi.c
    ../Drivers/BSP/tim/: timer.c
    ../Drivers/BSP/uart/: uart.c
    ../Drivers/DataFile/mem/: lis2mdl_reg.c lsm6ds3tr-c_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_ospi.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middle/MEMORY
    ../Middle/MALLOC/: malloc.c
  group Middle/SYSTEM
    ../Middle/SYSTEM/: sys.c
  group Middle/DELAY
    ../Middle/DELAY/: delay.c
  group USB/DEVICE/APP
    ../USB/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group USB/DEVICE/Target
    ../USB/Target/: usbd_conf.c
  group USB/DEVICE/Library
    ../USB/Class/CDC/Src/: usbd_cdc.c
    ../USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Fatfs
    ../FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group FreeRTOS/Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/MemMang/: heap_4.c heap_5.c
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group python-core
    ../python/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group python-api
    ../python/pikascript-api/: __asset_pikaModules_py_a.c __pikaBinding.c pikaScript.c
  group python-lib
    ../python/pikascript-lib/PikaStdLib/: PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_Dict.c PikaStdData_FILEIO.c PikaStdData_List.c PikaStdData_String.c PikaStdData_Tuple.c PikaStdData_Utils.c PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c PikaStdTask_Task.c
    ../python/pikascript-lib/time/: _time.c
    ../python/pikascript-lib/random/: _random.c
    ../python/pikascript-lib/math/: _math.c
    ../python/pikascript-lib/_thread/: _thread.c
    ../python/pikascript-lib/motor/: _motor.c
    ../python/pikascript-lib/matrix/: _matrix.c
    ../python/pikascript-lib/ultrasion/: _ultrasion.c
    ../python/pikascript-lib/touch/: _touch.c
    ../python/pikascript-lib/music/: _music.c
    ../python/pikascript-lib/message/: _message.c
    ../python/pikascript-lib/mem/: _mem.c
    ../python/pikascript-lib/list/: _list.c
    ../python/pikascript-lib/key/: _key.c
    ../python/pikascript-lib/gray/: _gray.c
    ../python/pikascript-lib/color/: _color.c
    ../python/pikascript-lib/os/: _os.c
    ../python/pikascript-lib/nfc/: _nfc.c
    ../python/pikascript-lib/camer/: _camer.c
    ../python/pikascript-lib/grayv2/: _grayv2.c
  group Library
    ../STM32_MotionFX_Library/Lib/: MotionFX_CM7F_wc16_ot.a
    ../Middle/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
  group X-CUBE-AI/APP
    ../X-CUBE-AI/App/: network.c network_data.c network_data_params.c
software components: CMSIS:CORE 6.1.1
